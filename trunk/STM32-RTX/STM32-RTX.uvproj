# Keil uVision project STM32-RTX.uvproj, settings and files
target STM32-RTX (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-RTX
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32L15XXB_128K
  c include: .\BSP;.\FWLib\CMSIS;.\FWLib\inc;.\FWLib\src;.\LCD_Driver;.\TouchSensing_Driver\inc;.\TouchSensing_Driver\src;.\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group BSP
    ./BSP/: system_stm32l1xx.c
  group FWLib
    ./FWLib/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_pwr.c stm32l1xx_exti.c stm32l1xx_syscfg.c stm32l1xx_lcd.c
    ./FWLib/CMSIS/: core_cm3.c
  group RTX
    ./RTX/: RTX_Config.c
  group LCD_Driver
    ./LCD_Driver/: stm32l_discovery_lcd.c
  group TouchSensing_Driver
    ./TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
  group User
    ./User/: main.c function.c
  group STARTUP
    ./: startup_stm32l1xx_md.s
