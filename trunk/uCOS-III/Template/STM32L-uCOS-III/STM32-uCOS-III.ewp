# IAR project STM32-uCOS-III.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: BSP\STM32L-DISCOVERY\inc; BSP\STM32L-DISCOVERY\src; BSP; LIB\CMSIS; LIB\STM32L1xx_StdPeriph_Driver\inc; LIB\STM32L1xx_StdPeriph_Driver\src; STARTUP; uCOS-III\uC-CPU\inc; uCOS-III\uC-CPU\src; uCOS-III\uC-LIB\inc; uCOS-III\uC-LIB\src; uCOS-III\uCOS-III\inc; uCOS-III\uCOS-III\src; USER\inc; USER\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-uCOS-III.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32-uCOS-III.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group BSP/STM32L-DISCOVERY/inc
    BSP/STM32L-DISCOVERY/inc/: discover_board.h stm32l_discovery_lcd.h
  group BSP/STM32L-DISCOVERY/src
    BSP/STM32L-DISCOVERY/src/: stm32l_discovery_lcd.c
  group LIB/CMSIS
    LIB/CMSIS/: arm_common_tables.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h
  group LIB/STM32L1xx_StdPeriph_Driver/inc
    LIB/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_dbgmcu.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_gpio.h stm32l1xx_lcd.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_syscfg.h
  group LIB/STM32L1xx_StdPeriph_Driver/src
    LIB/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c
  group STARTUP
    STARTUP/: startup_stm32l1xx_md.s
  group uCOS-III/uC/CPU/inc
    uCOS-III/uC-CPU/inc/: cpu.h cpu_cfg.h cpu_core.h cpu_def.h
  group uCOS-III/uC/CPU/src
    uCOS-III/uC-CPU/src/: cpu_a.asm cpu_c.c cpu_core.c
  group uCOS-III/uC/LIB/inc
    uCOS-III/uC-LIB/inc/: lib_ascii.h lib_cfg.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uCOS-III/uC/LIB/src
    uCOS-III/uC-LIB/src/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III/uC/OS-III/inc
    uCOS-III/uCOS-III/inc/: os.h os_app_hooks.h os_cfg.h os_cfg_app.h os_cpu.h os_type.h
  group uCOS-III/uC/OS-III/src
    uCOS-III/uCOS-III/src/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group USER/inc
    USER/inc/: app_cfg.h includes.h main.h stm32l1xx.h stm32l1xx_conf.h stm32l1xx_it.h system_stm32l1xx.h
  group USER/src
    USER/src/: main.c stm32l1xx_it.c system_stm32l1xx.c
