# Keil uVision project STM32L-uCOS.uvproj, settings and files
target STM32L-uCOS (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L-uCOS
  c flags: Optim=1
  c define: STM32L15XXB_128K USE_STDPERIPH_DRIVER
  c include: .\BSP;.\FWLib\CMSIS;.\FWLib\inc;.\FWLib\src;.\uC-CPU;.\uC-LIB;.\uC-LIB\Ports;.\uCOS-II\Ports;.\uCOS-II\Source;.\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group FWLib
    ./FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c system_stm32l1xx.c
    ./FWLib/CMSIS/: core_cm3.c
  group uC-CPU
    ./uC-CPU/: cpu_c.c cpu_a.asm
  group uC-LIB
    ./uC-LIB/: lib_mem.c lib_str.c
    ./uC-LIB/Ports/: lib_mem_a.asm
  group uCOS-II
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group User
    ./User/: main.c
  group STARTUP
    ./: startup_stm32l1xx_md.s
